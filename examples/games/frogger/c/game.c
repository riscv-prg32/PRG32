#include "prg32.h"
#include <stdio.h>

#define FROG_W 24
#define FROG_H 24
#define CELL 24
#define START_X 144
#define START_Y 168

typedef struct {
    int x;
    int y;
    int speed;
    uint16_t color;
} car_t;

static int frog_x;
static int frog_y;
static uint32_t last_input;
static uint32_t score;
static int state;
static car_t cars[4];

static const uint16_t frog_sprite[FROG_W * FROG_H] = {
    0xffff,0xffff,0xffff,0xffff,0xffff,0x07e0,0x07e0,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0x07e0,0x07e0,0xffff,0xffff,0xffff,0xffff,0xffff,
    0xffff,0xffff,0xffff,0xffff,0x07e0,0x07e0,0x07e0,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0x07e0,0x07e0,0x07e0,0xffff,0xffff,0xffff,0xffff,
    0xffff,0xffff,0xffff,0x07e0,0x07e0,0x07e0,0x07e0,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0x07e0,0x07e0,0x07e0,0x07e0,0xffff,0xffff,0xffff,
    0xffff,0xffff,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0xffff,0xffff,
    0xffff,0x07e0,0x07e0,0x07e0,0x0000,0x07e0,0x07e0,0x07e0,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0x07e0,0x07e0,0x07e0,0x0000,0x07e0,0x07e0,0x07e0,0x07e0,0xffff,
    0xffff,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0xffff,
    0xffff,0xffff,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0xffff,0xffff,0xffff,0xffff,0xffff,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0xffff,0xffff,
    0xffff,0xffff,0xffff,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0xffff,0xffff,0xffff,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0xffff,0xffff,0xffff,
    0xffff,0xffff,0xffff,0xffff,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0xffff,0xffff,0xffff,0xffff,
    0xffff,0xffff,0xffff,0xffff,0xffff,0x07e0,0x07e0,0x07e0,0xffe0,0xffe0,0x07e0,0x07e0,0x07e0,0x07e0,0xffe0,0xffe0,0x07e0,0x07e0,0x07e0,0xffff,0xffff,0xffff,0xffff,0xffff,
    0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0x07e0,0x07e0,0xffe0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0xffe0,0x07e0,0x07e0,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
    0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
    0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
    0xffff,0xffff,0xffff,0xffff,0xffff,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0xffff,0xffff,0xffff,0xffff,0xffff,
    0xffff,0xffff,0xffff,0xffff,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0xffff,0xffff,0xffff,0xffff,
    0xffff,0xffff,0xffff,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0x07e0,0xffff,0xffff,0xffff,
    0xffff,0xffff,0x07e0,0x07e0,0x07e0,0x07e0,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0x07e0,0x07e0,0x07e0,0x07e0,0xffff,0xffff,
    0xffff,0x07e0,0x07e0,0x07e0,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0x07e0,0x07e0,0x07e0,0xffff,
    0xffff,0x07e0,0x07e0,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0x07e0,0x07e0,0xffff,
    0xffff,0xffff,0x07e0,0x07e0,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0x07e0,0x07e0,0xffff,0xffff,
    0xffff,0xffff,0xffff,0x07e0,0x07e0,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0x07e0,0x07e0,0xffff,0xffff,0xffff,
    0xffff,0xffff,0xffff,0xffff,0x07e0,0x07e0,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0x07e0,0x07e0,0xffff,0xffff,0xffff,0xffff,
    0xffff,0xffff,0xffff,0xffff,0xffff,0x07e0,0x07e0,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0x07e0,0x07e0,0xffff,0xffff,0xffff,0xffff,0xffff,
    0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0x07e0,0x07e0,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,0x07e0,0x07e0,0xffff,0xffff,0xffff,0xffff,0xffff,0xffff,
};

static void reset_frog(void) {
    frog_x = START_X;
    frog_y = START_Y;
}

void frogger_c_init(void) {
    reset_frog();
    score = 0;
    state = 0;
    last_input = 0;
    cars[0] = (car_t){-40, 60, 2, PRG32_COLOR_RED};
    cars[1] = (car_t){270, 84, -3, PRG32_COLOR_YELLOW};
    cars[2] = (car_t){40, 108, 4, PRG32_COLOR_BLUE};
    cars[3] = (car_t){210, 132, -2, 0xf81f};
}

void frogger_c_update(void) {
    uint32_t input = prg32_input_read();
    uint32_t pressed = input & ~last_input;
    last_input = input;

    if (state != 0) {
        if (pressed & PRG32_BTN_A) {
            state = 0;
            reset_frog();
        }
        return;
    }

    if ((pressed & PRG32_BTN_LEFT) && frog_x > 0) {
        frog_x -= CELL;
    }
    if ((pressed & PRG32_BTN_RIGHT) && frog_x < PRG32_GAME_W - FROG_W) {
        frog_x += CELL;
    }
    if ((pressed & PRG32_BTN_UP) && frog_y > 0) {
        frog_y -= CELL;
    }
    if ((pressed & PRG32_BTN_DOWN) && frog_y < PRG32_GAME_H - FROG_H) {
        frog_y += CELL;
    }

    for (size_t i = 0; i < sizeof(cars) / sizeof(cars[0]); ++i) {
        cars[i].x += cars[i].speed;
        if (cars[i].speed > 0 && cars[i].x > PRG32_GAME_W) {
            cars[i].x = -56;
        }
        if (cars[i].speed < 0 && cars[i].x < -56) {
            cars[i].x = PRG32_GAME_W;
        }
        if (prg32_sprite_hitbox(frog_x + 4, frog_y + 4, 16, 16,
                                cars[i].x, cars[i].y, 48, 18)) {
            state = -1;
            prg32_audio_beep(120, 80);
        }
    }

    if (frog_y <= 24) {
        state = 1;
        score++;
        prg32_audio_beep(880, 80);
    }
}

void frogger_c_draw(void) {
    char text[24];

    prg32_gfx_clear(0x03ef);
    prg32_gfx_rect(0, 0, PRG32_GAME_W, 32, 0x05e0);
    prg32_gfx_rect(0, 56, PRG32_GAME_W, 100, 0x4208);
    prg32_gfx_rect(0, 176, PRG32_GAME_W, 24, 0x07e0);

    for (int y = 80; y <= 128; y += 24) {
        for (int x = 0; x < PRG32_GAME_W; x += 32) {
            prg32_gfx_rect(x, y, 16, 2, PRG32_COLOR_WHITE);
        }
    }

    for (size_t i = 0; i < sizeof(cars) / sizeof(cars[0]); ++i) {
        prg32_gfx_rect(cars[i].x, cars[i].y, 48, 18, cars[i].color);
        prg32_gfx_rect(cars[i].x + 6, cars[i].y + 3, 12, 4, PRG32_COLOR_WHITE);
        prg32_gfx_rect(cars[i].x + 30, cars[i].y + 3, 12, 4, PRG32_COLOR_WHITE);
    }

    prg32_sprite_draw_24x24(frog_x, frog_y, frog_sprite);

    snprintf(text, sizeof(text), "SCORE %lu", (unsigned long)score);
    prg32_gfx_text8(8, 8, text, PRG32_COLOR_WHITE, 0x05e0);
    if (state < 0) {
        prg32_gfx_text8(96, 92, "CRASH - A", PRG32_COLOR_WHITE, PRG32_COLOR_RED);
    } else if (state > 0) {
        prg32_gfx_text8(100, 92, "SAFE - A", PRG32_COLOR_BLACK, PRG32_COLOR_YELLOW);
    }
}
